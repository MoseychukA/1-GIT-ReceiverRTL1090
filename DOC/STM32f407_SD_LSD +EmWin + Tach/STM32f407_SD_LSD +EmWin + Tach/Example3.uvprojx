# Keil uVision project Example3.uvprojx, settings and files
target stm32f407 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Example3
  c flags: Optim=4 oTime=1 wLevel=2
  c include: .\CMSIS\Device\ST\STM32F4xx\Include;.\CMSIS\Device\ST\STM32F4xx\Source;.\CMSIS\Include;.\STM32F4xx_StdPeriph_Driver;.\STM32F4xx_StdPeriph_Driver\inc;.\STM32F4xx_StdPeriph_Driver\src;.\sourse;.\sourse\ADC;.\sourse\DAC;.\sourse\encoder;.\sourse\FATFS_SDIO;.\sourse\Flash;.\sourse\LCD_ILI9341_FSMC;.\sourse\parser;.\sourse\PWM;.\sourse\TIMERS;.\sourse\USART;.\sourse\LED_BUTTON;.\sourse\TouchPanel;.\sourse\EmWin;.\sourse\EmWin\Config;.\sourse\EmWin\inc;.\sourse\EmWin\OS;.\sourse\EmWin\Demo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./: startup_stm32f4xx.s
  group main
    ./sourse/: main.c main.h
  group CMSIS
    ./CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group StdPerph
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ./STM32F4xx_StdPeriph_Driver/: stm32f4xx_conf.h
  group TSC2046
    ./sourse/TouchPanel/: TouchPanel.c TouchPanel.h
  group ILI9143
    ./sourse/LCD_ILI9341_FSMC/: fonts.h tft_lcd.h fonts.c tft_lcd.c LCD_ini.h LCD_ini.c
  group EmWinOS
    ./sourse/EmWin/OS/: GUI_X.c
  group EmWin
    ./sourse/EmWin/Config/: GUIConf.h GUIDRV_Template.h LCDConf_FlexColor.h GUIConf.c LCDConf_FlexColor.c
    ./sourse/EmWin/: STemWin522_CM4_Keil.lib Arial16.c WindowDLG.c
  group EmWin_demo
    ./sourse/EmWin/Demo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
